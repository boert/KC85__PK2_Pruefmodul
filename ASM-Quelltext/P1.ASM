P1ASM 
 
 
 
;   Reparaturmodul PK2 f}r KC 85/4
 
;   PI/AUMY   2.11.88
 
 
 
PAD	EQU	88H
PAC	EQU	8AH
PBD	EQU	89H
PBC	EQU	8BH
CTCK0	EQU	8CH
CTCK1	EQU	8DH
CTCK2	EQU	8EH
VTZK1	EQU	50H
VTZK2	EQU	150H
 
 
 
	ORG	0E000H
 
;Sprungverteiler f}r TAB1 (Schalter P2)
 
PR20:	JP	TESTB
	NOP
PR21:	JP	PXTST
	NOP
PR22:	JP	FARBT
	NOP
PR23:	JP	RATST
	NOP
PR24:	JP	SIGT
	NOP
PR25:	JP	TONT
	NOP
PR26:	JP	TESTB	;KBTAPE !!
	NOP
PR27:	JP	TESTB
	NOP
 
;Sprungverteiler f}r TAB2 (Schalter P1)
 
PR10:	JP	RAMVE
	NOP
PR11:	JP	RAM5
	NOP
PR12:	JP	RAMA
	NOP
PR13:	JP	IRM5
	NOP
PR14:	JP	IRMA
	NOP
PR15:	JP	PIOTE
	NOP
PR16:	JP	CSCTC
	NOP
PR17:	JP	REGTE
 
 
 
 
	;TESTBILD FUER KC 85/4
	;=====================
 
 
TESTB:	LD	A,4FH
	OUT	(8AH),A
	LD	A,1FH
	OUT	(88H),A
	LD	A,0FH
	OUT	(8AH),A
	LD	A,03H
	OUT	(8AH),A
	LD	A,8	;PIXELSPEICHER1
	OUT	(84H),A
	LD	HL,8000H;PIXEL-RAM LADEN
	LD	DE,8001H
	LD	BC,800H
	LD	M,33H
	LDIR
	LD	BC,800H
	LD	M,55H
	LDIR
	LD	BC,800H
	LD	M,0
	LDIR
	LD	BC,800H
	LD	M,0FH
	LDIR
	LD	BC,100H
	LD	M,0
	LDIR
	LD	BC,100H
	LD	M,0FFH
	LDIR
	LD	BC,100H
	LD	M,0
	LDIR
	LD	BC,100H
	LD	M,0FFH
	LDIR
	LD	BC,100H
	LD	M,0
	LDIR
	LD	BC,100H
	LD	M,0FFH
	LDIR
	LD	BC,100H
	LD	M,0
	LDIR
	LD	BC,0FFH
	LD	M,0FFH
	LDIR
	LD	HL,8000H;ZEILEN LOESCHEN
MA	LD	A,H
	CP	0A8H
	JR	Z,ME
	LD	A,L
	AND	0C1H
	CP	0
	JR	Z,LOE
	LD	A,L
	AND	0C2H
	CP	40H
	JR	Z,LOE
	LD	A,L
	AND	0C4H
	CP	80H
	JR	Z,LOE
	LD	A,L
	AND	0C8H
	CP	0C0H
	JR	NZ,MZ
LOE	LD	M,0
MZ	INC	HL
	JR	MA
ME	LD	HL,8F40H;2xBYTE 0 BIS FF
	LD	DE,0C0H
	LD	C,8
	XOR	A
MC	LD	B,40H
	ADD	HL,DE
MB	LD	M,A
	INC	A
	INC	HL
	DJNZ	MB
	DEC	C
	JR	NZ,MC
	LD	HL,8F7FH;SCHRAEGE LINIE
	LD	DE,100H
	LD	C,8
	LD	A,80H
MLC	LD	B,8
	ADD	HL,DE
MLB	LD	M,A
	RRCA
	DEC	HL
	DJNZ	MLB
	DEC	C
	JR	NZ,MLC
	LD	HL,9000H;VORDERGRUND-
MFA	BIT	3,H	;FARBBALKEN
	JR	NZ,MFE
	LD	A,L
	AND	0C0H
	CP	0C0H
	JR	NZ,MFZ
	LD	M,0FFH
MFZ	INC	HL
	JR	MFA
	LD	A,3FH
	OUT	(88H),A
MFE	LD	A,0AH	;FARBSPEICHER1
	OUT	(84H),A
	LD	HL,8000H;FARB-RAM LADEN
	LD	DE,8001H
	LD	BC,27FFH
	LD	M,39H	;WEISS AUF BLAU
	LDIR
	LD	HL,9400H;BLINKFELD
MBA	LD	A,H
	CP	98H
	JR	Z,MBE
	LD	A,L
	AND	0C0H
	CP	0
	JR	NZ,MBZ
	LD	M,99H
MBZ	INC	HL
	JR	MBA
MBE	LD	HL,9000H;FARBBALKEN
	LD	DE,80H
	LD	C,8
	XOR	A
MFC	LD	B,80H
	ADD	HL,DE
MFB	RES	6,A
	BIT	5,L
	JR	Z,MFR
	SET	6,A
MFR	LD	M,A
	INC	HL
	DJNZ	MFB
	ADD	09H
	DEC	C
	JR	NZ,MFC
	LD	A,45H
	OUT	(8EH),A
	LD	A,19H
	OUT	(8EH),A
MW	JR	MW
 
 
 
 
	;TESTPROGRAMM FUER PIXELMODUS
	;============================
 
 
PXTST:	LD	A,4FH
	OUT	(8AH),A
	LD	A,1FH
	OUT	(88H),A
	LD	A,0FH
	OUT	(8AH),A
	OUT	(8BH),A
	LD	A,03H
	OUT	(8AH),A
	LD	A,00H
	OUT	(89H),A
	OUT	(84H),A	;SPEICHER FARBE1
	LD	HL,8000H;LINKER TEIL
	LD	DE,8001H
	LD	BC,80H
	LD	M,0
	LDIR
	LD	BC,7FH
	LD	M,0FFH
	LDIR
	LD	HL,8000H
	LD	DE,8100H
	LD	BC,1100H
	LDIR
	LD	HL,8280H;SENKR. LINIEN
	LD	DE,8281H
	LD	BC,7FH
	LD	M,7FH
	LDIR
	LD	HL,8600H
	LD	DE,8601H
	LD	BC,7FH
	LD	M,80H
	LDIR
	LD	HL,8200H
	LD	DE,8A00H
	LD	BC,500H
	LDIR
	LD	IY,7F90H;SCHRAEGE LIN.1
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MSC	LD	B,8
	ADD	IY,DE
MSB	LD	L,(IY)
	LD	A,H
	CPL
	AND	L
	LD	(IY),A
	LD	L,(IY+20H)
	LD	A,H
	OR	L
	LD	(IY+20H),A
	LD	L,(IY+40H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+40H),A
	LD	L,(IY+60H)
	LD	A,H
	OR	L
	LD	(IY+60H),A
	RRC	H
	DEC	IY
	DJNZ	MSB
	DEC	C
	JR	NZ,MSC
	LD	IY,7F10H;SCHRAEGE LIN.2
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MTC	LD	B,8
	ADD	IY,DE
MTB	LD	L,(IY)
	LD	A,H
	OR	L
	LD	(IY),A
	LD	L,(IY+20H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+20H),A
	LD	L,(IY+40H)
	LD	A,H
	OR	L
	LD	(IY+40H),A
	LD	L,(IY+60H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+60H),A
	RRC	H
	INC	IY
	DJNZ	MTB
	DEC	C
	JR	NZ,MTC
	LD	HL,9000H;AUFLOESUNGSRAS-
	LD	DE,9001H	;TER
	LD	BC,40H
	LD	M,55H
	LDIR
	LD	BC,40H
	LD	M,33H
	LDIR
	LD	BC,40H
	LD 	M,0FH
	LDIR
	LD	BC,40H
	LD	M,0
	LDIR
	LD	HL,9000H
	LD	DE,9100H
	LD	BC,0C0H
	LDIR
	LD	HL,9000H
	LD	DE,9200H
	LD	BC,200H
	LDIR
	LD	HL,9400H
	LD	DE,9401H
	LD	BC,3FFH
	LD	M,0FFH
	LDIR
	LD	HL,9400H;ZEILEN LOESCHEN
MTA	LD	A,H
	CP	98H
	JR	Z,MTE
	LD	A,L
	AND	0C1H
	CP	0
	JR	Z,LOET
	LD	A,L
	AND	0C2H
	CP	40H
	JR	Z,LOET
	LD	A,L
	AND	0C4H
	CP	80H
	JR	Z,LOET
	LD	A,L
	AND	0C8H
	CP	0C0H
	JR	NZ,MTZ
LOET	LD	M,0
MTZ	INC	HL
	JR	MTA
MTE	LD	HL,8000H;RECHTER TEIL
	LD	DE,9800H
	LD	BC,1000H
	LDIR
	LD	A,3FH
	OUT	(88H),A
	LD	A,02H
	OUT	(84H),A	;SPEICHER FARBE2
	LD	HL,8000H
	LD	DE,8001H
	LD	BC,1000H
	LD	M,0
	LDIR
	LD	BC,400H
	LD	M,0FFH
	LDIR
	LD	BC,100H
	LD	M,0
	LDIR
	LD	BC,12FFH
	LD	M,0FFH
	LDIR
	LD	HL,9000H;ZEILEN LOESCHEN
MUA	LD	A,H
	CP	94H
	JR	Z,MUE
	LD	A,L
	AND	0C1H
	CP	0
	JR	Z,LOEU
	LD	A,L
	AND	0C2H
	CP	40H
	JR	Z,LOEU
	LD	A,L
	AND	0C4H
	CP	80H
	JR	Z,LOEU
	LD	A,L
	AND	0C8H
	CP	0C0H
	JR	NZ,MUZ
LOEU	LD   	M,0
MUZ	INC	HL
	JR	MUA
MUE	LD	HL,9400H
	LD	DE,9401H
	LD	BC,40H
	LD	M,55H
	LDIR
	LD	BC,40H
	LD	M,33H
	LDIR
	LD	BC,3FH
	LD	M,0FH
	LDIR
	LD	HL,9400H
	LD	DE,9500H
	LD	BC,0C0H
	LDIR
	LD	HL,9400H
	LD	DE,9600H
	LD	BC,200H
	LDIR
	LD	HL,8A00H;SENKR.	LINIEN
	LD	DE,8A01H
	LD	BC,0FFH
	LD	M,80H
	LDIR
	LD	HL,8A00H
	LD	DE,8E00H
	LD	BC,100H
	LDIR
	LD	HL,9A00H
	LD	DE,9A01H
	LD	BC,0FFH
	LD	M,7FH
	LDIR
	LD	HL,9A00H
	LD	DE,9E00H
	LD	BC,100H
	LDIR
	LD	IY,7F90H;SCHRAEGE LINIE1
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MUC	LD	B,8
	ADD	IY,DE
MUB	LD	L,(IY+40H)
	LD	A,H
	OR	L
	LD	(IY+40H),A
	LD	L,(IY+60H)
	LD	A,H
	OR	L
	LD	(IY+60H),A
	RRC	H
	DEC	IY
	DJNZ	MUB
	DEC	C
	JR	NZ,MUC
	LD	IY,7F10H;SCHRAEGE LINIE2
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MVC	LD	B,8
	ADD	IY,DE
MVB	LD	L,(IY)
	LD	A,H
	OR	L
	LD	(IY),A
	LD	L,(IY+20H)
	LD	A,H
	OR	L
	LD	(IY+20H),A
	RRC	H
	INC	IY
	DJNZ	MVB
	DEC	C
	JR	NZ,MVC
	LD	IY,9790H;SCHRAEGE LINIE3
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MWC	LD	B,8
	ADD	IY,DE
MWB	LD	L,(IY)
	LD	A,H
	CPL
	AND	L
	LD	(IY),A
	LD	L,(IY+20H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+20H),A
	RRC	H
	DEC	IY
	DJNZ	MWB
	DEC	C
	JR	NZ,MWC
	LD	IY,9710H;SCHRAEGE LINIE4
	LD	DE,100H
	LD	C,10H
	LD	H,80H
MXC	LD	B,8
	ADD	IY,DE
MXB	LD	L,(IY+40H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+40H),A
	LD	L,(IY+60H)
	LD	A,H
	CPL
	AND	L
	LD	(IY+60H),A
	RRC	H
	INC	IY
	DJNZ	MXB
	DEC	C
	JR	NZ,MXC
MXX	JR	MXX
 
 
 
 
	;RAMTEST FUER KC 85/4
	;====================
 
 
RATST:	LD	A,4FH
	OUT	(8AH),A
	LD	A,2FH	;INITIALISIERUNG
	OUT	(88H),A
	LD	A,0FH
	OUT	(8AH),A
	OUT	(8BH),A
	LD	A,03H
	OUT	(8AH),A
	OUT	(8BH),A
	CALL	CLS
	LD	SP,0A000H
	LD	HL,RAMT
	CALL	TEXT
	LD	IY,8920H
	LD	HL,SCHU
	CALL	TEXT
	LD	B,20H
	LD	DE,100H
	LD	IY,812BH
LIN	LD	(IY),0FFH
	LD	(IY+1),0FFH
	ADD	IY,DE
	DJNZ	LIN
	DI
;	PUSH	IX
	LD	IX,RATA;TABELLE DER ZU
	LD	B,6	;TEST SPEICHERBL
BLOCK0	EXX
	LD	B,(IX+7)
	LD	C,(IX+6)
	PUSH	BC
	POP	IY
	LD	H,(IX+9)
	LD	L,(IX+8)
	CALL	TEXT
	LD	H,(IX+1)
	LD	L,(IX)
	LD	A,(IX+2)
	OUT	(84H),A
	LD	A,(IX+3)
	OUT	(86H),A
	LD	A,(IX+4)
	OUT	(88H),A
	LD	A,(IX+5)
	OUT	(89H),A
	BIT 	0,(IX+10);SCHREIBSCHUTZ?
	JR	Z,KSCH1
	LD	A,M
	LD	B,A
	CPL
	LD	M,A
	LD	A,M
	CP	B
	EXX
	JR	Z,SCHTZ
	LD	HL,FEHLER
	JR	KSCH
SCHTZ	LD	HL,OK
KSCH	LD	A,(IX+7)
	LD	E,(IX+6)
	ADD	8
	LD	D,A
	LD	A,2FH
	OUT	(88H),A
	LD	A,08H
	OUT	(84H),A
	PUSH	DE
	POP	IY
	CALL	TEXT
	LD	A,(IX+4)
	OUT	(88H),A
	LD	A,(IX+2)
	OUT	(84H),A
	EXX
KSCH1	LD	B,(IX+12);SCHUTZ AUS
	LD	C,(IX+11)
	OUT	(C),B
	EX	DE,HL	;PRUEFBER. LADEN
	LD	HL,RATST
	EXX
	LD	C,81H
UMLA	EXX
	LD	HL,RATST
	LD	BC,7FH
	LDIR
	EXX
	DEC	C
	JR	NZ,UMLA
	EXX
	XOR	A
	LD	(DE),A
	LD	H,(IX+1);VERGLEICH
	LD	L,(IX)
	LD	C,81H
VERC	LD	B,7FH
	LD	IY,RATST
VERB	LD	A,(IY)
	CP	M
	JR	NZ,VERFE
	INC	HL
	INC	IY
	DJNZ	VERB
	DEC	C
	JR	NZ,VERC
	XOR	A
	CP	M
	JR	NZ,VERFE
	LD	H,(IX+1);SPEICHER NEGIER
	LD	L,(IX)
	LD	DE,4000H
WE	LD	A,M
	CPL
	LD	M,A
	INC	HL
	DEC	DE
	XOR	A
	CP	D
	JR	NZ,WE
	CP	E
	JR	NZ,WE
	LD	H,(IX+1);VERGLEICH
	LD	L,(IX)
	LD	C,81H
VERRC	LD	B,7FH
	LD	IY,RATST
VERRB	LD	A,(IY)
	CPL
	CP	M
	JR	NZ,VERFE
	INC	HL
	INC	IY
	DJNZ	VERRB
	DEC	C
	JR	NZ,VERRC
	LD	A,0FFH
	CP	M
	JR	NZ,VERFE
	LD	HL,OK
	JR	AUGA
VERFE	LD	HL,FEHLER
AUGA	LD	A,(IX+7)
	LD	E,(IX+6)
	ADD	10H
	LD	D,A
	LD	A,2FH
	OUT	(88H),A
	LD	A,08H
	OUT	(84H),A
	PUSH	DE
	POP	IY
	CALL	TEXT
	LD	A,(IX+4)
	OUT	(88H),A
	LD	A,(IX+2)
	OUT	(84H),A
	LD	B,(IX+12)
	LD	C,(IX+11)
	OUT	(C),B
	JP	OHNRE	;??
 
;REFRESHTEST ??
;	LD	HL,1400H;WARTESCHLEIFE
;WART0	LD	B,0FFH
;WART1	DJNZ	WART1
;	DEC	HL
;	XOR	A
;	CP	H
;	JR	NZ,WART0
;	CP	L
;	JR	NZ,WART0
;	LD	H,(IX+1);REFRESHTEST
;	LD	L,(IX)
;	LD	C,81H
;VERFC	LD	B,7FH
;	LD	IY,RATST
;VERFB	LD	A,(IY)
;	CPL
;	CP	M
;	JR	NZ,RFFE
;	INC	HL
;	INC	IY
;	DJNZ	VERFB
;	DEC	C
;	JR	NZ,VERFC
;	LD	A,0FFH
;	CP	M
;	JR	NZ,RFFE
;	LD	HL,OK	;AUSGABE
;	JR	AUGR
;RFFE	LD	HL,FEHLER
;AUGR	LD	A,(IX+7)
;	LD	E,(IX+6)
;	ADD	18H
;	LD	D,A
 
OHNRE	LD	A,2FH
	OUT	(88H),A
	LD	A,08H
	OUT	(84H),A
;	PUSH	DE
;	POP	IY
;	CALL	TEXT
	LD	DE,10H
	ADD	IX,DE	;NAECHSTER BLOCK
	EXX
	DJNZ	BLOCK
ENDE	JR	ENDE
BLOCK	JP	BLOCK0
	;
	;UP ZUR	TEXTAUSGABE
	;------------------
ZG	EQU	0FE00H	;ZEICHENGENERAT.
	;IY=ANFANGSPOSITION
	;HL=STRINGANFANG
	;-------------------------------
TEXT	PUSH	DE
	PUSH	AF
	PUSH	HL
	PUSH	BC
TEXT1	LD	A,M
	CP	0
	CALL	NZ,TEXT2
	POP	BC
	POP	HL
	POP	AF
	POP	DE
	RET
 
;AUSGABE EINES BYTES (A)
TEXBY	PUSH	AF
	SRL	A
	SRL	A
	SRL	A
	SRL	A
	ADD	30H
	CP	3AH
	JR	C,TEXB2
	ADD	7
TEXB2	CALL	TEXAS
	POP	AF
	AND	0FH
	ADD	30H
	CP	3AH
	JR	C,TEXB3
	ADD	7
TEXB3	CALL	TEXAS
	DEC	HL
	DEC	HL	;WEGEN TEXAS
	RET
 
TEXT2	POP	DE
	LD	DE,TEXT1
	PUSH	DE		;RETADR
 
;AUSGABE EINES ASCII-ZEICHENS (A)+INC HL
TEXAS	PUSH	HL
	PUSH	DE
	PUSH	BC
	LD	HL,ZG
	SUB	20H
	LD	B,0
	LD	C,A
	SLA	C
	SLA	C
	RL	B
	SLA	C
	RL	B
	ADD	HL,BC
	LD	B,8
TEXT3	LD	A,M
	LD	(IY),A
	INC	HL
	INC	IY
	DJNZ	TEXT3
	LD	BC,0F8H
	ADD	IY,BC
	POP	BC
	POP	DE
	POP	HL
	INC	HL
	RET
	;
	;STRINGSAMMLUNG
	;--------------
RAMT	DEFM    '>>> RAMT'
	DEFM	'EST FUER'
	DEFM	' KC 85/4'
	DEFM	' <<<'
	DEFB	0
SCHU	DEFM	'SCHUTZ  '
	DEFM	'WR/RD   '
;	DEFM	'RFSH'
	DEFB	0
OK	DEFM 	'OK'
	DEFB	0
FEHLER	DEFM	'FEHLER'
	DEFB	0
RAM0	DEFM	'RAM 0'
	DEFB	0
RAM4	DEFM	'RAM 4'
	DEFB	0
PIX2	DEFM	'PIX 2'
	DEFB	0
FARB2	DEFM	'FARB 2'
	DEFB	0
RAF3	DEFM	'RAF 3'
	DEFB	0
RAF4	DEFM	'RAF 4'
	DEFB	0
TON	DEFM	'TONTEST'
	DEFB	0
KBD	DEFM	'KBD'
	DEFB	0
TAPE	DEFM	'TAPE'
	DEFB	0
RCW	DEFM	'FEHLER RAS/CAS/WR'
	DEFB	0
KFA	DEFM	'ADRESSEN  OK'
	DEFB	0
KDF	DEFM	'DATEN     OK'
	DEFB	0
ABFEH	DEFM	'FEHLER BEI AB'
	DEFB	0
DBFEH	DEFM	'FEHLER BEI DB'
	DEFB	0
PIN	DEFM	'  PIN '
	DEFB	0
RT55	DEFM	'RAMTEST MIT 55H'
	DEFB	0
RTAA	DEFM	'RAMTEST MIT AAH'
	DEFB	0
TCTC	DEFM	'CTC-TEST  K0-K2'
	DEFB	0
TPIO	DEFM	'PIO-TEST  0-255'
	DEFB	0
TREG	DEFM	'REG-TEST  0-255'
	DEFB	0
TBLOK	DEFM	'BLOCKTEST OK'
	DEFB	0
TBLER	DEFM	'BLOCKTEST FEHLER '
	DEFB	0
TSIC	DEFM	'SIG CAOS-ROM C: '
	DEFB	0
TSIB	DEFM	'SIG BASIC-ROM : '
	DEFB	0
 
 
 
 
	;
	;SPEICHERBLOCKTABELLE
	;--------------------
RATA	DEFB 	00H
	DEFB	00H
	DEFB	08H
	DEFB	00H
	DEFB	07H
	DEFB	00H
	DEFB	30H
	DEFB	81H
	DEFW	RAM0
	DEFB	01H
	DEFB	88H
	DEFB	0FH
	DEFB	00H
	DEFB	00H
	DEFB	00H
	;
	DEFB	00H
	DEFB	40H
	DEFB	08H
	DEFB	01H
	DEFB	05H
	DEFB	00H
	DEFB	40H
	DEFB	81H
	DEFW	RAM4
	DEFB	01H
	DEFB	86H
	DEFB	03H
	DEFB	00H
	DEFB	00H
	DEFB	00H
	;
	DEFB	00H
	DEFB	80H
	DEFB	0CH
	DEFB	00H
	DEFB	05H
	DEFB	00H
	DEFB	50H
	DEFB	81H
	DEFW	PIX2
	DEFB	00H
	DEFB	84H
	DEFB	0CH
	DEFB	00H
	DEFB	00H
	DEFB	00H
	;
	DEFB	00H
	DEFB	80H
	DEFB	0EH
	DEFB	00H
	DEFB	05H
	DEFB	00H
	DEFB	60H
	DEFB	81H
	DEFW	FARB2
	DEFB	00H
	DEFB	84H
	DEFB	0EH
	DEFB	00H
	DEFB	00H
	DEFB	00H
	;
	DEFB	00H
	DEFB	80H
	DEFB	28H
	DEFB	00H
	DEFB	01H
	DEFB	20H
	DEFB	70H
	DEFB	81H
	DEFW	RAF3
	DEFB	01H
	DEFB	89H
	DEFB	60H
	DEFB	00H
	DEFB	00H
	DEFB	00H
	;
	DEFB	00H
	DEFB	80H
	DEFB	38H
	DEFB	00H
	DEFB	01H
	DEFB	20H
	DEFB	80H
	DEFB	81H
	DEFW	RAF4
	DEFB	01H
	DEFB	89H
	DEFB	60H
	DEFB	00H
	DEFB	00H
	DEFB	00H
 
 
 
 
 
;----------------
;
; TONTEST KC85/4
;
;----------------
 
TONT:	DI
	IM	2
	LD	A,98H
	LD	I,A
	LD	IX,9000H
	LD	(IX),0
	LD	SP,0A000H
	LD	A,4FH
	OUT	PAC
	OUT	PBC
	LD	A,3FH
	OUT	PAD
	LD	A,0FH
	OUT	PAC
	OUT	PBC
	LD	A,03H
	OUT	PAC
	OUT	PBC
	CALL	CLS
	LD	HL,INTER
	LD	(980CH),HL
	LD	HL,TON	;TEXTAUSGABE
	CALL	TEXT
	LD	A,8
	OUT	CTCK0
	EI
TONI2	LD	HL,TABELLE
	LD	B,20	;16+4 TOENE
TONI1	PUSH	BC
	LD	C,M
	INC	HL
	LD	B,M
	INC	HL
	LD	E,M
	INC	HL
	LD	D,M
	INC	HL
	LD	A,M
	INC	HL
	INC	HL
	PUSH	HL
	DEC	HL
	LD	H,M
	LD	L,A
	CALL	TON0
	POP	HL
	POP	BC
	DJNZ	TONI1
	JR	TONI2
;
TON0	BIT	1,(IX)
	JR	NZ,TON0
;
TONB	LD	A,C
	XOR	1FH
	LD	C,A
	LD	A,B
	AND	A ;TONLAENGE=0?
	JR	Z,TON1
	SET	1,(IX)
	LD	A,0C7H ;ZAEHLER M. INT.
	OUT	CTCK2
	LD	A,B	;TONLAENGE
	OUT	CTCK2
;
TON1	LD	A,C
	SCF
	RLA
	OUT	PBD    ;LAUTSTAERKE
	LD	C,CTCK1 ;2. KANAL
	CALL	TON2
	DEC	C	;1.KANAL
	EX	DE,HL
;
TON2	LD	A,L ;TONHOEHE
	AND	A   ;=0?
	LD	L,3 ;BEI L=0
	JR	Z,TON4
	LD	L,A
	LD	A,7
	BIT	0,H ;VORTEILER?
	JR	Z,TON3 ;VORTEILER 16
	OR	20H    ;VORTEILER 256
;
TON3	OUT	(C),A ;STEUERWORT
TON4	OUT	(C),L ;TONHOEHE (BEI
		      ;L=0 STEUERWORT)
	RET
;
INTER	PUSH	AF
	LD	A,3
	OUT	CTCK0
	OUT	CTCK1
	RES	1,(IX)
;	LD	A,47H
;	OUT	CTCK2
;	LD	A,20H
;	OUT	CTCK2
	POP	AF
	EI
	RETI
;
TABELLE	DEFW	0201H ;TON1
	DEFW	010H
	DEFW	120H
;
	DEFW	0302H ;TON2
	DEFW	018H
	DEFW	128H
;
	DEFW	0403H ;TON2
	DEFW	020H
	DEFW	130H
;
	DEFW	0504H ;TON4
	DEFW	028H
	DEFW	138H
;
	DEFW	0605H ;TON5
	DEFW	030H
	DEFW	140H
;
	DEFW	0706H ;TON6
	DEFW	038H
	DEFW	148H
;
	DEFW	0807H ;TON7
	DEFW	040H
	DEFW	150H
;
	DEFW	0908H ;TON8
	DEFW	048H
	DEFW	158H
;
	DEFW	0A09H ;TON9
	DEFW	050H
	DEFW	160H
;
	DEFW	0B0AH ;TON10
	DEFW	058H
	DEFW	168H
;
	DEFW	0C0BH ;TON11
	DEFW	060H
	DEFW	170H
;
	DEFW	0D0CH ;TON12
	DEFW	068H
	DEFW	178H
;
	DEFW	0E0DH ;TON13
	DEFW	070H
	DEFW	180H
;
	DEFW	0F0EH ;TON14
	DEFW	078H
	DEFW	188H
;
	DEFW	100FH ;TON15
	DEFW	080H
	DEFW	190H
;
	DEFW	1100H ;TON16
	DEFW	088H
	DEFW	198H
 
	DEFW	1101H
	DEFW	VTZK1
	DEFW	VTZK2
	DEFW	1102H
	DEFW	VTZK1
	DEFW	VTZK2
	DEFW	1104H
	DEFW	VTZK1
	DEFW	VTZK2
	DEFW	1108H
	DEFW	VTZK1
	DEFW	VTZK2
;---------------------------------------
 
ENDT1:	EQU	#
ÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿÿ